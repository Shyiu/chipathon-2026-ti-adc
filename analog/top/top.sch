** sch_path: analog/top/top.sch
**.subckt top
V8 CLK 0 PWL(0 3.3 100n 3.3 101n 0 200n 0 201n 3.3 1300n 3.3)
V3 VDD 0 3.3
V1 RST 0 PULSE(3.3 0 0 1n 1n 15n 100000n)
V6 VIN 0 1.5
V2 VRef 0 1.8
V9 CLK_N 0 PWL(0 0 100n 0 101n 3.3 200n 3.3 201n 0 1300n 0)
x3 OUTN OUTP CLK_O 0 VDD VX VCM realcomp
x4 0 VDD CTRL2 CTRL1 CTRL0 CTRL3 net3 net4 net1 net2 CTRL5 CTRL7 CTRL4 CTRL6 net5 net6 net8 net7
+ inverter_block
x6 VDD VSAMPLE CLK_N VIN 0 transmission_gate
X1 VDD 0 CLK CLK_O CTRL0 CTRL1 CTRL2 CTRL3 CTRL4 CTRL5 CTRL6 CTRL7 DOUT0 DOUT1 DOUT2 DOUT3 DOUT4
+ DOUT5 DOUT6 DOUT7 OUTP OUTN RST sar_adc_logic
x2 VDD net1 net2 net3 VSAMPLE net4 0 VDD net5 net6 VRef net8 CLK net7 0 VDD CTRL0 VX CTRL1 CTRL2
+ VX_LSB CTRL3 0 CLK_N CTRL4 VCM CTRL5 CTRL6 CTRL7 caps2
V4 VCM 0 1.65
**** begin user architecture code


.subckt sar_adc_logic VDD VSS clk_i clk_o dac_ctrl[0] dac_ctrl[1] dac_ctrl[2] dac_ctrl[3]
+  dac_ctrl[4] dac_ctrl[5] dac_ctrl[6] dac_ctrl[7] dout[0] dout[1] dout[2] dout[3]  dout[4] dout[5] dout[6]
+ dout[7] out_n out_p rst_n
XFILLER_22_177 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
Xdly_stage[203].delay_buf dly_stage[203].delay_buf/I dly_stage[204].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[132].delay_buf dly_stage[132].delay_buf/I dly_stage[133].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_27_236 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_10_103 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_12_10 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_5_4 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_TAPCELL_ROW_8_88 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_24_217 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_24_239 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XPHY_EDGE_ROW_20_Left_50 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[84].delay_buf dly_stage[84].delay_buf/I dly_stage[85].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_23_86 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_23_97 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
X_062_ input2/Z _104_/Q _105_/Q _063_/B VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__aoi21_1
XFILLER_21_209 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_20_220 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[33].delay_buf dly_stage[33].delay_buf/I dly_stage[34].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_045_ _083_/Q _059_/A1 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__clkinv_1
Xdly_stage[253].delay_buf dly_stage[253].delay_buf/I dly_stage[254].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xhold30 _081_/Q _095_/D VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyc_1
Xdly_stage[182].delay_buf dly_stage[182].delay_buf/I dly_stage[183].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_26_109 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[202].delay_buf dly_stage[202].delay_buf/I dly_stage[203].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_25_142 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
Xoutput7 _083_/Q dac_ctrl[4] VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyd_1
Xdly_stage[131].delay_buf dly_stage[131].delay_buf/I dly_stage[132].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_13_178 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_9_127 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[83].delay_buf dly_stage[83].delay_buf/I dly_stage[84].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_10_115 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_5_185 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_TAPCELL_ROW_8_89 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[32].delay_buf dly_stage[32].delay_buf/I dly_stage[33].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_23_240 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XPHY_EDGE_ROW_12_Right_12 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_EDGE_ROW_21_Right_21 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[252].delay_buf dly_stage[252].delay_buf/I dly_stage[253].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_061_ _061_/A1 _103_/Q _061_/B _082_/D VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__oai21_1
Xedge_dly_stage[2].edge_delay_buf edge_dly_stage[2].edge_delay_buf/I
+ edge_dly_stage[3].edge_delay_buf/I  VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_7_236 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XTAP_TAPCELL_ROW_5_79 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
X_044_ _084_/Q _057_/A1 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__clkinv_1
Xdly_stage[181].delay_buf dly_stage[181].delay_buf/I dly_stage[182].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[201].delay_buf dly_stage[201].delay_buf/I dly_stage[202].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_29_129 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_4_239 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xhold31 _088_/Q _096_/D VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyc_1
Xdly_stage[130].delay_buf dly_stage[130].delay_buf/I dly_stage[131].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xclkbuf_1_1__f_valid_clk_regs clkbuf_0_valid_clk_regs/Z _101_/CLK VDD VDD VSS VSS
+  gf180mcu_fd_sc_mcu7t5v0__clkbuf_16
Xdly_stage[149].delay_buf dly_stage[149].delay_buf/I dly_stage[150].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_25_176 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XPHY_EDGE_ROW_6_Right_6 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xstart_pulse_and clkload0/I start_pulse_and/A2 start_pulse_and/Z VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__and2_1
Xdly_stage[82].delay_buf dly_stage[82].delay_buf/I dly_stage[83].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xoutput10 _088_/Q dac_ctrl[7] VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyd_1
Xoutput8 _082_/Q dac_ctrl[5] VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyd_1
XFILLER_22_113 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
Xedge_dly_stage[7].edge_delay_buf edge_dly_stage[7].edge_delay_buf/I
+ edge_dly_stage[8].edge_delay_buf/I  VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_13_135 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xdly_stage[31].delay_buf dly_stage[31].delay_buf/I dly_stage[32].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_5_142 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[251].delay_buf dly_stage[251].delay_buf/I dly_stage[252].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[180].delay_buf dly_stage[180].delay_buf/I dly_stage[181].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[200].delay_buf dly_stage[200].delay_buf/I dly_stage[201].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[199].delay_buf dly_stage[199].delay_buf/I dly_stage[200].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_060_ input2/Z _103_/Q _104_/Q _061_/B VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__aoi21_1
XFILLER_20_233 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_29_2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_32
Xdly_stage[219].delay_buf dly_stage[219].delay_buf/I dly_stage[220].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XPHY_EDGE_ROW_8_Left_38 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
X_043_ _085_/Q _055_/A1 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__clkinv_1
Xdly_stage[148].delay_buf dly_stage[148].delay_buf/I dly_stage[149].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_20_34 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_28_163 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_3_240 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[81].delay_buf dly_stage[81].delay_buf/I dly_stage[82].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_19_174 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_25_188 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xoutput11 _089_/Q dout[0] VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyd_1
Xoutput9 _081_/Q dac_ctrl[6] VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyd_1
Xdly_stage[30].delay_buf dly_stage[30].delay_buf/I dly_stage[31].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_16_199 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
Xdly_stage[49].delay_buf dly_stage[49].delay_buf/I dly_stage[50].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_13_158 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_TAPCELL_ROW_15_109 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[250].delay_buf dly_stage[250].delay_buf/I dly_stage[251].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_27_206 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_27_228 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_5_132 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[198].delay_buf dly_stage[198].delay_buf/I dly_stage[199].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_24_209 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[218].delay_buf dly_stage[218].delay_buf/I dly_stage[219].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_15_209 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[147].delay_buf dly_stage[147].delay_buf/I dly_stage[148].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XPHY_EDGE_ROW_24_Left_54 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[80].delay_buf dly_stage[80].delay_buf/I dly_stage[81].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xedge_dly_stage[13].edge_delay_buf edge_dly_stage[13].edge_delay_buf/I
+ edge_dly_stage[14].edge_delay_buf/I  VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__buf_1
X_042_ _086_/Q _053_/A1 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__clkinv_1
Xdly_stage[99].delay_buf dly_stage[99].delay_buf/I dly_stage[99].delay_buf/Z  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_4_219 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_19_142 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
Xdly_stage[48].delay_buf dly_stage[48].delay_buf/I dly_stage[49].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_25_101 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_25_123 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XPHY_EDGE_ROW_11_Left_41 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xoutput12 _090_/Q dout[1] VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyd_1
XTAP_TAPCELL_ROW_18_118 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_26_34 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[197].delay_buf dly_stage[197].delay_buf/I dly_stage[198].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[217].delay_buf dly_stage[217].delay_buf/I dly_stage[218].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XTAP_TAPCELL_ROW_20_124 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_5_144 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[146].delay_buf dly_stage[146].delay_buf/I dly_stage[147].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_17_240 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_23_68 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_TAPCELL_ROW_0_60 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[98].delay_buf dly_stage[98].delay_buf/I dly_stage[99].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XTAP_TAPCELL_ROW_9_91 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_11_224 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_1_2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_7_228 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
X_041_ _087_/Q _051_/A1 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__clkinv_1
Xdly_stage[47].delay_buf dly_stage[47].delay_buf/I dly_stage[48].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xclkload0 clkload0/I clkload0/Z VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__clkbuf_2
XFILLER_19_198 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_20_8 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
Xdly_stage[196].delay_buf dly_stage[196].delay_buf/I dly_stage[197].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xcomp_trigger_driver comp_trigger_driver/I clk_o VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__buf_16
XFILLER_0_201 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xoutput13 _091_/Q dout[2] VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyd_1
XFILLER_16_157 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XPHY_EDGE_ROW_19_Right_19 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_EDGE_ROW_28_Right_28 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XTAP_TAPCELL_ROW_18_119 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[216].delay_buf dly_stage[216].delay_buf/I dly_stage[217].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[145].delay_buf dly_stage[145].delay_buf/I dly_stage[146].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_21_182 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XTAP_TAPCELL_ROW_23_133 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_12_171 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_12_37 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XTAP_TAPCELL_ROW_20_125 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[97].delay_buf dly_stage[97].delay_buf/I dly_stage[98].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xclkbuf_0_valid_clk valid_clk_xor/Z clkbuf_0_valid_clk/Z VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__clkbuf_16
XFILLER_23_36 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_32
Xdly_stage[46].delay_buf dly_stage[46].delay_buf/I dly_stage[47].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_13_80 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_TAPCELL_ROW_0_61 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_TAPCELL_ROW_9_92 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xclkload1 _080_/A1 clkload1/ZN VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__clkinv_3
XFILLER_27_2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_64
Xdly_stage[195].delay_buf dly_stage[195].delay_buf/I dly_stage[196].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xhold24 _082_/Q _094_/D VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyc_1
Xdly_stage[215].delay_buf dly_stage[215].delay_buf/I dly_stage[216].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_19_166 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_TAPCELL_ROW_6_82 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[144].delay_buf dly_stage[144].delay_buf/I dly_stage[145].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XTAP_TAPCELL_ROW_26_142 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xoutput14 _092_/Q dout[3] VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyd_1
Xclkbuf_1_0__f_eoc clkbuf_0_eoc/Z comp_trigger_nor/A2 VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__clkbuf_16
Xclkbuf_1_0__f_clk_i clkbuf_0_clk_i/Z _107_/I VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__clkbuf_16
Xdly_stage[96].delay_buf dly_stage[96].delay_buf/I dly_stage[97].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_13_139 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_TAPCELL_ROW_23_134 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_8_198 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_18_209 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XTAP_TAPCELL_ROW_20_126 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[45].delay_buf dly_stage[45].delay_buf/I dly_stage[46].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_23_212 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
Xdly_stage[194].delay_buf dly_stage[194].delay_buf/I dly_stage[195].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XTAP_TAPCELL_ROW_0_62 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_TAPCELL_ROW_9_93 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_18_15 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_7_208 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[214].delay_buf dly_stage[214].delay_buf/I dly_stage[215].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xclkload2 _105_/CLK clkload2/Z VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__clkbuf_2
XPHY_EDGE_ROW_28_Left_58 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[143].delay_buf dly_stage[143].delay_buf/I dly_stage[144].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_099_ _100_/Q _099_/RN _101_/CLK _099_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XFILLER_20_16 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_28_101 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_29_36 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_32
Xhold25 _085_/Q _091_/D VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyc_1
XFILLER_28_167 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_28_189 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_6_18 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XTAP_TAPCELL_ROW_29_151 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_TAPCELL_ROW_6_83 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[95].delay_buf dly_stage[95].delay_buf/I dly_stage[96].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_0_203 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_16_104 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XPHY_EDGE_ROW_1_Right_1 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XTAP_TAPCELL_ROW_26_143 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xoutput15 _093_/Q dout[4] VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyd_1
XFILLER_15_181 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_7_72 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XPHY_EDGE_ROW_15_Left_45 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[44].delay_buf dly_stage[44].delay_buf/I dly_stage[45].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_26_37 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XTAP_TAPCELL_ROW_23_135 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_29_240 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_8_177 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_TAPCELL_ROW_3_73 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[193].delay_buf dly_stage[193].delay_buf/I dly_stage[194].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[213].delay_buf dly_stage[213].delay_buf/I dly_stage[214].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[142].delay_buf dly_stage[142].delay_buf/I dly_stage[143].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_20_216 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XTAP_TAPCELL_ROW_0_63 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_11_238 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_24_92 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XPHY_EDGE_ROW_3_Left_33 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[94].delay_buf dly_stage[94].delay_buf/I dly_stage[95].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_098_ _099_/Q _098_/RN _101_/CLK _098_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XTAP_TAPCELL_ROW_10_94 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xhold26 _084_/Q _092_/D VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyc_1
XFILLER_27_190 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_TAPCELL_ROW_29_152 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_TAPCELL_ROW_6_84 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[43].delay_buf dly_stage[43].delay_buf/I dly_stage[44].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_15_17 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_TAPCELL_ROW_26_144 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xoutput16 _094_/Q dout[5] VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyd_1
XFILLER_21_163 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XPHY_EDGE_ROW_15_Right_15 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_EDGE_ROW_24_Right_24 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[192].delay_buf dly_stage[192].delay_buf/I dly_stage[193].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_12_185 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_TAPCELL_ROW_3_74 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[212].delay_buf dly_stage[212].delay_buf/I dly_stage[213].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[141].delay_buf dly_stage[141].delay_buf/I dly_stage[142].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XTAP_TAPCELL_ROW_0_64 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[93].delay_buf dly_stage[93].delay_buf/I dly_stage[94].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[109].delay_buf dly_stage[109].delay_buf/I dly_stage[110].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xedge_dly_stage[0].edge_delay_buf _107_/I edge_dly_stage[1].edge_delay_buf/I VDD  VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[42].delay_buf dly_stage[42].delay_buf/I dly_stage[43].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_097_ _098_/Q _097_/RN _101_/CLK _097_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XFILLER_3_224 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XTAP_TAPCELL_ROW_10_95 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xhold27 _083_/Q _093_/D VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyc_1
XFILLER_19_158 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XTAP_TAPCELL_ROW_29_153 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_25_139 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_25_2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_64
Xoutput17 _095_/Q dout[6] VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyd_1
Xdly_stage[191].delay_buf dly_stage[191].delay_buf/I dly_stage[192].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_21_72 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xdly_stage[211].delay_buf dly_stage[211].delay_buf/I dly_stage[212].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_7_85 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xedge_dly_stage[5].edge_delay_buf edge_dly_stage[5].edge_delay_buf/I
+ edge_dly_stage[6].edge_delay_buf/I  VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[140].delay_buf dly_stage[140].delay_buf/I dly_stage[141].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_21_142 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_21_186 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[159].delay_buf dly_stage[159].delay_buf/I dly_stage[160].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_12_19 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_8_179 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_TAPCELL_ROW_3_75 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[92].delay_buf dly_stage[92].delay_buf/I dly_stage[93].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_17_212 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_17_234 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xdly_stage[108].delay_buf dly_stage[108].delay_buf/I dly_stage[109].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_23_204 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XTAP_TAPCELL_ROW_0_65 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[41].delay_buf dly_stage[41].delay_buf/I dly_stage[42].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_11_207 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_1_10 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xdly_stage[190].delay_buf dly_stage[190].delay_buf/I dly_stage[191].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_096_ _096_/D _048_/I _096_/CLK _096_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XTAP_TAPCELL_ROW_10_96 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xhold28 _087_/Q _089_/D VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyc_1
XFILLER_19_61 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_27_181 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_TAPCELL_ROW_29_154 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[210].delay_buf dly_stage[210].delay_buf/I dly_stage[211].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_0_206 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_15_19 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_18_2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xoutput18 _096_/Q dout[7] VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyd_1
Xdly_stage[229].delay_buf dly_stage[229].delay_buf/I dly_stage[230].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_079_ _079_/A1 _079_/A2 _087_/RN VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_24_173 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[158].delay_buf dly_stage[158].delay_buf/I dly_stage[159].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_15_162 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_21_121 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XPHY_EDGE_ROW_5_Right_5 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[91].delay_buf dly_stage[91].delay_buf/I dly_stage[92].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[107].delay_buf dly_stage[107].delay_buf/I dly_stage[108].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_8_103 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XPHY_EDGE_ROW_19_Left_49 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[40].delay_buf dly_stage[40].delay_buf/I dly_stage[41].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_27_72 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_5_128 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xdly_stage[59].delay_buf dly_stage[59].delay_buf/I dly_stage[60].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_23_238 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_20_208 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_9_220 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_TAPCELL_ROW_0_66 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xedge_dly_stage[11].edge_delay_buf edge_dly_stage[11].edge_delay_buf/I
+ edge_dly_stage[12].edge_delay_buf/I  VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[228].delay_buf dly_stage[228].delay_buf/I dly_stage[229].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_095_ _095_/D _048_/I _096_/CLK _095_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
Xhold29 _086_/Q _090_/D VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyc_1
Xdly_stage[157].delay_buf dly_stage[157].delay_buf/I dly_stage[158].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_19_40 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XPHY_EDGE_ROW_7_Left_37 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XTAP_TAPCELL_ROW_29_155 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[90].delay_buf dly_stage[90].delay_buf/I dly_stage[91].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_078_ _079_/A1 _078_/A2 _086_/RN VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__nor2_1
Xdly_stage[106].delay_buf dly_stage[106].delay_buf/I dly_stage[107].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_12_177 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_16_41 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XPHY_EDGE_ROW_11_Right_11 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_EDGE_ROW_20_Right_20 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XTAP_TAPCELL_ROW_14_106 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[58].delay_buf dly_stage[58].delay_buf/I dly_stage[59].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_17_203 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xdly_stage[227].delay_buf dly_stage[227].delay_buf/I dly_stage[228].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_8_2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_11_209 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[156].delay_buf dly_stage[156].delay_buf/I dly_stage[157].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_10_231 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_6_213 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
X_094_ _094_/D _048_/I _096_/CLK _094_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XPHY_EDGE_ROW_23_Left_53 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[105].delay_buf dly_stage[105].delay_buf/I dly_stage[106].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_19_63 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_27_183 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_TAPCELL_ROW_29_156 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_25_109 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
X_077_ _079_/A1 _080_/A2 _085_/RN VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__nor2_1
Xdly_stage[57].delay_buf dly_stage[57].delay_buf/I dly_stage[58].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_15_142 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_15_197 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XTAP_TAPCELL_ROW_17_115 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_21_101 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XPHY_EDGE_ROW_10_Left_40 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_29_201 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_TAPCELL_ROW_14_107 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[226].delay_buf dly_stage[226].delay_buf/I dly_stage[227].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[155].delay_buf dly_stage[155].delay_buf/I dly_stage[156].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_9_222 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[104].delay_buf dly_stage[104].delay_buf/I dly_stage[105].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xclkbuf_0_clk_i clk_i clkbuf_0_clk_i/Z VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__clkbuf_16
X_093_ _093_/D _048_/I _096_/CLK _093_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XFILLER_19_42 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_28_107 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xinput1 out_n input1/Z VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyd_1
Xdly_stage[56].delay_buf dly_stage[56].delay_buf/I dly_stage[57].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XTAP_TAPCELL_ROW_29_157 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xclkbuf_0_valid_clk_regs clkbuf_regs_0_valid_clk/Z clkbuf_0_valid_clk_regs/Z VDD VDD  VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__clkbuf_16
X_076_ _079_/A1 _080_/A2 _084_/RN VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_18_173 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_21_76 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_TAPCELL_ROW_17_116 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_16_2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xdly_stage[225].delay_buf dly_stage[225].delay_buf/I dly_stage[226].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_059_ _059_/A1 _102_/Q _059_/B _083_/D VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__oai21_1
XTAP_TAPCELL_ROW_14_108 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_TAPCELL_ROW_22_130 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XPHY_EDGE_ROW_9_Right_9 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[154].delay_buf dly_stage[154].delay_buf/I dly_stage[155].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_17_238 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[103].delay_buf dly_stage[103].delay_buf/I dly_stage[104].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_23_208 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_9_212 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
Xdly_stage[55].delay_buf dly_stage[55].delay_buf/I dly_stage[56].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_6_237 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xclkbuf_0_eoc_regs clkbuf_0_eoc_regs/I clkbuf_0_eoc_regs/Z VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__clkbuf_16
X_092_ _092_/D _048_/I _092_/CLK _092_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XFILLER_3_207 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xinput2 out_p input2/Z VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__buf_1
X_075_ _080_/A1 _080_/A2 _083_/RN VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__nor2_1
Xdly_stage[224].delay_buf dly_stage[224].delay_buf/I dly_stage[225].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_24_100 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_24_111 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_24_177 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XTAP_TAPCELL_ROW_17_117 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xmax_cap20 _079_/A2 _080_/A2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__buf_2
Xdly_stage[153].delay_buf dly_stage[153].delay_buf/I dly_stage[154].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_058_ _058_/A1 _102_/Q _103_/Q _059_/B VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__aoi21_1
XFILLER_21_136 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_29_203 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_TAPCELL_ROW_22_131 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[102].delay_buf dly_stage[102].delay_buf/I dly_stage[103].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[54].delay_buf dly_stage[54].delay_buf/I dly_stage[55].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_10_212 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_10_223 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_6_2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
Xdly_stage[223].delay_buf dly_stage[223].delay_buf/I dly_stage[224].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_091_ _091_/D _048_/I _092_/CLK _091_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XPHY_EDGE_ROW_18_Right_18 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_EDGE_ROW_27_Right_27 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_27_142 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[152].delay_buf dly_stage[152].delay_buf/I dly_stage[153].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_074_ _080_/A1 _080_/A2 _082_/RN VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__nor2_1
XPHY_EDGE_ROW_27_Left_57 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[101].delay_buf dly_stage[101].delay_buf/I dly_stage[102].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XTAP_TAPCELL_ROW_25_140 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xmax_cap21 input2/Z _058_/A1 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__buf_2
Xclkbuf_1_0__f_valid_clk clkbuf_0_valid_clk/Z comp_trigger_nor/A1 VDD VDD VSS VSS
+  gf180mcu_fd_sc_mcu7t5v0__clkbuf_16
X_057_ _057_/A1 _101_/Q _057_/B _084_/D VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__oai21_1
XPHY_EDGE_ROW_0_Right_0 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XTAP_TAPCELL_ROW_22_132 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[53].delay_buf dly_stage[53].delay_buf/I dly_stage[54].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xclkbuf_0_start_pulse start_pulse_and/Z clkbuf_0_start_pulse/Z VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__clkbuf_16
XPHY_EDGE_ROW_14_Left_44 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_17_207 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_25_240 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_27_66 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_4_37 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_9_203 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xdly_stage[222].delay_buf dly_stage[222].delay_buf/I dly_stage[223].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[151].delay_buf dly_stage[151].delay_buf/I dly_stage[152].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_24_34 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
X_090_ _090_/D _048_/I _092_/CLK _090_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XFILLER_27_198 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_3_209 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[100].delay_buf dly_stage[99].delay_buf/Z dly_stage[101].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XPHY_EDGE_ROW_2_Left_32 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[119].delay_buf dly_stage[119].delay_buf/I dly_stage[120].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_073_ _080_/A1 _080_/A2 _081_/RN VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__nor2_1
XTAP_TAPCELL_ROW_25_141 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[52].delay_buf dly_stage[52].delay_buf/I dly_stage[53].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_056_ _058_/A1 _101_/Q _102_/Q _057_/B VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__aoi21_1
XFILLER_21_149 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xedge_dly_stage[3].edge_delay_buf edge_dly_stage[3].edge_delay_buf/I
+ edge_dly_stage[4].edge_delay_buf/I  VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_16_13 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xdly_stage[221].delay_buf dly_stage[221].delay_buf/I dly_stage[222].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[169].delay_buf dly_stage[169].delay_buf/I dly_stage[170].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[150].delay_buf dly_stage[150].delay_buf/I dly_stage[151].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_9_237 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xedge_dly_stage[8].edge_delay_buf edge_dly_stage[8].edge_delay_buf/I
+ edge_dly_stage[9].edge_delay_buf/I  VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_24_79 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_6_229 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
Xdly_stage[118].delay_buf dly_stage[118].delay_buf/I dly_stage[119].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_5_240 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_10_26 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_10_37 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_19_57 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_27_122 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_27_133 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_27_155 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
Xdly_stage[51].delay_buf dly_stage[51].delay_buf/I dly_stage[52].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_18_111 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_18_177 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XTAP_TAPCELL_ROW_28_150 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
X_072_ _080_/A1 _078_/A2 _072_/ZN VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_24_125 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_24_169 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_15_136 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_15_158 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_23_180 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_7_38 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
X_055_ _055_/A1 _100_/Q _055_/B _085_/D VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__oai21_1
Xdly_stage[19].delay_buf dly_stage[19].delay_buf/I dly_stage[20].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_16_6 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_12_117 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_29_206 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_32
Xdly_stage[220].delay_buf dly_stage[220].delay_buf/I dly_stage[221].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_11_150 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[239].delay_buf dly_stage[239].delay_buf/I dly_stage[240].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_107_ _107_/I _107_/Z VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_17_209 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[168].delay_buf dly_stage[168].delay_buf/I dly_stage[169].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[117].delay_buf dly_stage[117].delay_buf/I dly_stage[118].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_24_69 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xdly_stage[69].delay_buf dly_stage[69].delay_buf/I dly_stage[70].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[50].delay_buf dly_stage[50].delay_buf/I dly_stage[51].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_4_2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XPHY_EDGE_ROW_14_Right_14 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_EDGE_ROW_23_Right_23 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[18].delay_buf dly_stage[18].delay_buf/I dly_stage[19].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_071_ _080_/A1 _078_/A2 _104_/RN VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_24_104 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[238].delay_buf dly_stage[238].delay_buf/I dly_stage[239].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_21_129 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
X_054_ _058_/A1 _100_/Q _101_/Q _055_/B VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__aoi21_1
Xedge_dly_stage[14].edge_delay_buf edge_dly_stage[14].edge_delay_buf/I
+ edge_dly_stage[15].edge_delay_buf/I  VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[167].delay_buf dly_stage[167].delay_buf/I dly_stage[168].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_16_37 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_20_162 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_11_184 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XPHY_EDGE_ROW_4_Right_4 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[116].delay_buf dly_stage[116].delay_buf/I dly_stage[117].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XPHY_EDGE_ROW_18_Left_48 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[68].delay_buf dly_stage[68].delay_buf/I dly_stage[69].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_0_172 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_0_194 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_10_216 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_24_37 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_32
Xdly_stage[17].delay_buf dly_stage[17].delay_buf/I dly_stage[18].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_10_28 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_2_223 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
Xdly_stage[237].delay_buf dly_stage[237].delay_buf/I dly_stage[238].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_070_ _080_/A1 _079_/A2 _103_/RN VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_2_73 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xdly_stage[166].delay_buf dly_stage[166].delay_buf/I dly_stage[167].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XPHY_EDGE_ROW_6_Left_36 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
X_053_ _053_/A1 _099_/Q _053_/B _086_/D VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__oai21_1
Xdly_stage[115].delay_buf dly_stage[115].delay_buf/I dly_stage[116].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_14_193 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_20_130 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XTAP_TAPCELL_ROW_13_103 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
X_105_ _105_/D _072_/ZN _105_/CLK _105_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffsnq_1
Xdly_stage[67].delay_buf dly_stage[67].delay_buf/I dly_stage[68].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_25_200 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_12_2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_22_214 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xdly_stage[16].delay_buf dly_stage[16].delay_buf/I dly_stage[17].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_9_207 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_9_229 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_8_240 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[236].delay_buf dly_stage[236].delay_buf/I dly_stage[237].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_10_239 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[165].delay_buf dly_stage[165].delay_buf/I dly_stage[166].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_10_18 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_19_49 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
Xdly_stage[114].delay_buf dly_stage[114].delay_buf/I dly_stage[115].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XPHY_EDGE_ROW_22_Left_52 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_23_194 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
X_052_ _058_/A1 _099_/Q _100_/Q _053_/B VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__aoi21_1
XTAP_TAPCELL_ROW_16_112 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[66].delay_buf dly_stage[66].delay_buf/I dly_stage[67].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XTAP_TAPCELL_ROW_13_104 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_11_142 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_19_231 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
Xdly_stage[15].delay_buf dly_stage[15].delay_buf/I dly_stage[16].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_104_ _105_/Q _104_/RN _105_/CLK _104_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffrnq_2
Xclkbuf_regs_1_eoc_clk _097_/Q clkbuf_0_eoc_regs/I VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__clkbuf_16
XFILLER_22_237 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xdly_stage[235].delay_buf dly_stage[235].delay_buf/I dly_stage[236].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_13_237 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xdly_stage[164].delay_buf dly_stage[164].delay_buf/I dly_stage[165].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_5_41 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_8_230 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
Xdly_stage[113].delay_buf dly_stage[113].delay_buf/I dly_stage[114].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xclkbuf_1_1__f_eoc_regs clkbuf_0_eoc_regs/Z _092_/CLK VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__clkbuf_16
XFILLER_27_104 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_27_126 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[65].delay_buf dly_stage[65].delay_buf/I dly_stage[66].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_24_107 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XPHY_EDGE_ROW_10_Right_10 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XTAP_TAPCELL_ROW_19_121 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_2_2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
X_051_ _051_/A1 _098_/Q _051_/B _087_/D VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__oai21_1
XTAP_TAPCELL_ROW_16_113 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_TAPCELL_ROW_7_85 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[14].delay_buf dly_stage[14].delay_buf/I dly_stage[15].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xclkbuf_1_1__f_start_pulse clkbuf_0_start_pulse/Z _079_/A1 VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__clkbuf_16
XFILLER_11_176 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XTAP_TAPCELL_ROW_13_105 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[234].delay_buf dly_stage[234].delay_buf/I dly_stage[235].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_103_ _104_/Q _103_/RN _105_/CLK _103_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffrnq_2
Xdly_stage[9].delay_buf dly_stage[9].delay_buf/I dly_stage[9].delay_buf/Z VDD  VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[163].delay_buf dly_stage[163].delay_buf/I dly_stage[164].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_17_72 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XPHY_EDGE_ROW_8_Right_8 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xclkbuf_1_0__f_eoc_regs clkbuf_0_eoc_regs/Z _096_/CLK VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__clkbuf_16
XFILLER_13_205 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_9_209 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xvalid_clk_xor input2/Z input1/Z valid_clk_xor/Z VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__xor2_4
Xdly_stage[112].delay_buf dly_stage[112].delay_buf/I dly_stage[113].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_5_234 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xdly_stage[64].delay_buf dly_stage[64].delay_buf/I dly_stage[65].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_25_72 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_4_6 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[13].delay_buf dly_stage[13].delay_buf/I dly_stage[14].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XTAP_TAPCELL_ROW_19_122 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
X_050_ _058_/A1 _098_/Q _099_/Q _051_/B VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__aoi21_1
XFILLER_14_174 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_TAPCELL_ROW_16_114 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_TAPCELL_ROW_7_86 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[8].delay_buf dly_stage[8].delay_buf/I dly_stage[9].delay_buf/I VDD  VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[233].delay_buf dly_stage[233].delay_buf/I dly_stage[234].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_20_111 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_20_166 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_20_177 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_28_2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_32
Xdly_stage[162].delay_buf dly_stage[162].delay_buf/I dly_stage[163].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_11_188 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
X_102_ _103_/Q _102_/RN _105_/CLK _102_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffrnq_2
Xdly_stage[111].delay_buf dly_stage[111].delay_buf/I dly_stage[112].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_25_236 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XTAP_TAPCELL_ROW_4_76 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[63].delay_buf dly_stage[63].delay_buf/I dly_stage[64].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xcomp_trigger_nor comp_trigger_nor/A1 comp_trigger_nor/A2 _079_/A1 comp_trigger_nor/ZN  VDD VDD VSS
+ VSS gf180mcu_fd_sc_mcu7t5v0__nor3_4
XFILLER_0_110 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_10_2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
Xdly_stage[12].delay_buf dly_stage[12].delay_buf/I dly_stage[13].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[232].delay_buf dly_stage[232].delay_buf/I dly_stage[233].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_2_77 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_TAPCELL_ROW_19_123 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[7].delay_buf dly_stage[7].delay_buf/I dly_stage[8].delay_buf/I VDD  VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[161].delay_buf dly_stage[161].delay_buf/I dly_stage[162].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_23_142 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XTAP_TAPCELL_ROW_11_97 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XPHY_EDGE_ROW_26_Left_56 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XTAP_TAPCELL_ROW_7_87 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xedge_dly_stage[1].edge_delay_buf edge_dly_stage[1].edge_delay_buf/I
+ edge_dly_stage[2].edge_delay_buf/I  VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[110].delay_buf dly_stage[110].delay_buf/I dly_stage[111].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[129].delay_buf dly_stage[129].delay_buf/I dly_stage[130].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_101_ _102_/Q _101_/RN _101_/CLK _101_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffrnq_2
XFILLER_19_212 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[62].delay_buf dly_stage[62].delay_buf/I dly_stage[63].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XTAP_TAPCELL_ROW_4_77 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_13_218 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_22_218 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XPHY_EDGE_ROW_13_Left_43 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[11].delay_buf dly_stage[11].delay_buf/I dly_stage[12].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_21_240 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xedge_dly_stage[6].edge_delay_buf edge_dly_stage[6].edge_delay_buf/I
+ edge_dly_stage[7].edge_delay_buf/I  VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_14_20 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
Xdly_stage[6].delay_buf dly_stage[6].delay_buf/I dly_stage[7].delay_buf/I VDD  VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[231].delay_buf dly_stage[231].delay_buf/I dly_stage[232].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XTAP_TAPCELL_ROW_1_67 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[160].delay_buf dly_stage[160].delay_buf/I dly_stage[161].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_2_239 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_4_8 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[179].delay_buf dly_stage[179].delay_buf/I dly_stage[180].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_18_107 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_25_85 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XTAP_TAPCELL_ROW_11_98 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xmax_cap19 _079_/A2 _078_/A2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__buf_2
Xdly_stage[128].delay_buf dly_stage[128].delay_buf/I dly_stage[129].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xclkbuf_1_0__f_valid_clk_regs clkbuf_0_valid_clk_regs/Z _105_/CLK VDD VDD VSS VSS
+  gf180mcu_fd_sc_mcu7t5v0__clkbuf_16
XFILLER_14_154 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_23_176 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XPHY_EDGE_ROW_1_Left_31 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[61].delay_buf dly_stage[61].delay_buf/I dly_stage[62].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_20_168 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_22_53 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
X_100_ _101_/Q _100_/RN _101_/CLK _100_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffrnq_2
XFILLER_0_2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
Xdly_stage[10].delay_buf dly_stage[9].delay_buf/Z dly_stage[11].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_3_142 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_TAPCELL_ROW_4_78 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[29].delay_buf dly_stage[29].delay_buf/I dly_stage[30].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[230].delay_buf dly_stage[230].delay_buf/I dly_stage[231].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XPHY_EDGE_ROW_17_Right_17 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_EDGE_ROW_26_Right_26 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[5].delay_buf dly_stage[5].delay_buf/I dly_stage[6].delay_buf/I VDD  VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[249].delay_buf dly_stage[249].delay_buf/I dly_stage[250].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[178].delay_buf dly_stage[178].delay_buf/I dly_stage[179].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_14_32 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_29_160 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XTAP_TAPCELL_ROW_1_68 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_27_108 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[127].delay_buf dly_stage[127].delay_buf/I dly_stage[128].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_1_240 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_26_174 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
X_105__22 _105_/D VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__tiel
XFILLER_2_79 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[60].delay_buf dly_stage[60].delay_buf/I dly_stage[61].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XTAP_TAPCELL_ROW_11_99 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_TAPCELL_ROW_25_139 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[79].delay_buf dly_stage[79].delay_buf/I dly_stage[80].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_14_177 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
Xedge_dly_stage[12].edge_delay_buf edge_dly_stage[12].edge_delay_buf/I
+ edge_dly_stage[13].edge_delay_buf/I  VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[28].delay_buf dly_stage[28].delay_buf/I dly_stage[29].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_26_2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_32
Xdly_stage[4].delay_buf dly_stage[4].delay_buf/I dly_stage[5].delay_buf/I VDD  VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[248].delay_buf dly_stage[248].delay_buf/I dly_stage[249].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_12_8 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[177].delay_buf dly_stage[177].delay_buf/I dly_stage[178].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_13_209 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[126].delay_buf dly_stage[126].delay_buf/I dly_stage[127].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_29_172 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_29_194 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_5_238 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_TAPCELL_ROW_1_69 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[78].delay_buf dly_stage[78].delay_buf/I dly_stage[79].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_25_76 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_26_164 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XTAP_TAPCELL_ROW_28_148 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_23_134 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xdly_stage[27].delay_buf dly_stage[27].delay_buf/I dly_stage[28].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[3].delay_buf dly_stage[3].delay_buf/I dly_stage[4].delay_buf/I VDD  VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[247].delay_buf dly_stage[247].delay_buf/I dly_stage[248].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xclk_i_dly_inv_23 clk_i_dly_inv_23/I start_pulse_and/A2 VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__inv_1
Xdly_stage[176].delay_buf dly_stage[176].delay_buf/I dly_stage[177].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_19_2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
X_089_ _089_/D _048_/I _092_/CLK _089_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XFILLER_17_22 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_17_33 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[125].delay_buf dly_stage[125].delay_buf/I dly_stage[126].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XPHY_EDGE_ROW_3_Right_3 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_EDGE_ROW_17_Left_47 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[77].delay_buf dly_stage[77].delay_buf/I dly_stage[78].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_14_34 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[26].delay_buf dly_stage[26].delay_buf/I dly_stage[27].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_25_66 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XTAP_TAPCELL_ROW_28_149 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_17_187 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
Xrst_root rst_n _048_/I VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__buf_8
Xdly_stage[2].delay_buf dly_stage[2].delay_buf/I dly_stage[3].delay_buf/I VDD  VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[246].delay_buf dly_stage[246].delay_buf/I dly_stage[247].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_23_168 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
Xdly_stage[175].delay_buf dly_stage[175].delay_buf/I dly_stage[176].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_22_34 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XPHY_EDGE_ROW_5_Left_35 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[124].delay_buf dly_stage[124].delay_buf/I dly_stage[125].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_25_208 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_TAPCELL_ROW_12_100 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
X_088_ _088_/D _080_/ZN _105_/CLK _088_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffsnq_1
XTAP_TAPCELL_ROW_8_90 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[76].delay_buf dly_stage[76].delay_buf/I dly_stage[77].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_0_70 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XPHY_EDGE_ROW_13_Right_13 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_EDGE_ROW_22_Right_22 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XTAP_TAPCELL_ROW_5_80 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[25].delay_buf dly_stage[25].delay_buf/I dly_stage[26].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_5_207 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_5_218 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
Xdly_stage[245].delay_buf dly_stage[245].delay_buf/I dly_stage[246].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[1].delay_buf dly_stage[1].delay_buf/I dly_stage[2].delay_buf/I VDD  VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[174].delay_buf dly_stage[174].delay_buf/I dly_stage[175].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_17_122 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_17_166 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_25_78 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_26_177 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_23_158 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XTAP_TAPCELL_ROW_2_70 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[123].delay_buf dly_stage[123].delay_buf/I dly_stage[124].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_9_195 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XPHY_EDGE_ROW_21_Left_51 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_22_79 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_10_183 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_19_206 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_19_239 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_8_26 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_8_37 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_TAPCELL_ROW_12_101 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[75].delay_buf dly_stage[75].delay_buf/I dly_stage[76].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_087_ _087_/D _087_/RN _101_/CLK _087_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XFILLER_17_24 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[24].delay_buf dly_stage[24].delay_buf/I dly_stage[25].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_21_212 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_24_2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_28_34 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[244].delay_buf dly_stage[244].delay_buf/I dly_stage[245].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[0].delay_buf comp_trigger_nor/ZN dly_stage[1].delay_buf/I VDD VDD VSS  VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_8_238 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_TAPCELL_ROW_5_81 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[173].delay_buf dly_stage[173].delay_buf/I dly_stage[174].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_29_186 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[122].delay_buf dly_stage[122].delay_buf/I dly_stage[123].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_26_101 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_26_156 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XTAP_TAPCELL_ROW_2_71 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_23_115 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[74].delay_buf dly_stage[74].delay_buf/I dly_stage[75].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_20_107 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XTAP_TAPCELL_ROW_15_110 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_10_173 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_27_240 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_TAPCELL_ROW_12_102 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[23].delay_buf dly_stage[23].delay_buf/I dly_stage[24].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_086_ _086_/D _086_/RN _101_/CLK _086_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XFILLER_18_240 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xclkbuf_regs_0_valid_clk valid_clk_xor/Z clkbuf_regs_0_valid_clk/Z VDD VDD VSS VSS
+  gf180mcu_fd_sc_mcu7t5v0__clkbuf_16
Xdly_stage[243].delay_buf dly_stage[243].delay_buf/I dly_stage[244].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_17_2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_23_90 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[172].delay_buf dly_stage[172].delay_buf/I dly_stage[173].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_069_ _080_/A1 _079_/A2 _102_/RN VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_14_37 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XPHY_EDGE_ROW_7_Right_7 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[121].delay_buf dly_stage[121].delay_buf/I dly_stage[122].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_5_209 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_1_212 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
Xdly_stage[73].delay_buf dly_stage[73].delay_buf/I dly_stage[74].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xclkbuf_0_eoc _097_/Q clkbuf_0_eoc/Z VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__clkbuf_16
XFILLER_17_168 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_2_18 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_TAPCELL_ROW_2_72 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_23_138 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[22].delay_buf dly_stage[22].delay_buf/I dly_stage[23].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_22_171 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_3_72 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_3_83 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_TAPCELL_ROW_15_111 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[242].delay_buf dly_stage[242].delay_buf/I dly_stage[243].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_22_37 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_8_28 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_10_196 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
Xdly_stage[171].delay_buf dly_stage[171].delay_buf/I dly_stage[172].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_085_ _085_/D _085_/RN _101_/CLK _085_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XPHY_EDGE_ROW_9_Left_39 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[120].delay_buf dly_stage[120].delay_buf/I dly_stage[121].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_068_ _080_/A1 _078_/A2 _101_/RN VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_21_236 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xdly_stage[139].delay_buf dly_stage[139].delay_buf/I dly_stage[140].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xedge_dly_stage[4].edge_delay_buf edge_dly_stage[4].edge_delay_buf/I
+ edge_dly_stage[5].edge_delay_buf/I  VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_7_240 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[72].delay_buf dly_stage[72].delay_buf/I dly_stage[73].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xclkbuf_1_0__f_start_pulse clkbuf_0_start_pulse/Z _080_/A1 VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__clkbuf_16
Xdly_stage[21].delay_buf dly_stage[21].delay_buf/I dly_stage[22].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XTAP_TAPCELL_ROW_18_120 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[241].delay_buf dly_stage[241].delay_buf/I dly_stage[242].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xedge_dly_stage[9].edge_delay_buf edge_dly_stage[9].edge_delay_buf/I
+ edge_dly_stage[9].edge_delay_buf/Z  VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[170].delay_buf dly_stage[170].delay_buf/I dly_stage[171].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_13_194 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_9_176 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[189].delay_buf dly_stage[189].delay_buf/I dly_stage[190].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XPHY_EDGE_ROW_29_Right_29 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[209].delay_buf dly_stage[209].delay_buf/I dly_stage[210].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xclkbuf_1_1__f_clk_i clkbuf_0_clk_i/Z clkload0/I VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__clkbuf_16
XFILLER_8_18 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XPHY_EDGE_ROW_25_Left_55 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[138].delay_buf dly_stage[138].delay_buf/I dly_stage[139].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_084_ _084_/D _084_/RN _101_/CLK _084_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XFILLER_15_212 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[71].delay_buf dly_stage[71].delay_buf/I dly_stage[72].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_0_108 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_9_72 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
X_067_ _079_/A1 _079_/A2 _100_/RN VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_12_204 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_28_37 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_22_2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_32
Xdly_stage[20].delay_buf dly_stage[20].delay_buf/I dly_stage[21].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_14_28 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_29_112 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_29_145 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XPHY_EDGE_ROW_12_Left_42 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[39].delay_buf dly_stage[39].delay_buf/I dly_stage[40].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[240].delay_buf dly_stage[240].delay_buf/I dly_stage[241].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[259].delay_buf dly_stage[259].delay_buf/I comp_trigger_driver/I VDD  VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_17_126 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_1_236 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xdly_stage[188].delay_buf dly_stage[188].delay_buf/I dly_stage[189].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_23_107 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_14_107 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xedge_dly_stage[10].edge_delay_buf edge_dly_stage[9].edge_delay_buf/Z
+ edge_dly_stage[11].edge_delay_buf/I  VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[208].delay_buf dly_stage[208].delay_buf/I dly_stage[209].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_3_74 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[137].delay_buf dly_stage[137].delay_buf/I dly_stage[138].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XTAP_TAPCELL_ROW_21_127 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_18_232 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XPHY_EDGE_ROW_0_Left_30 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[70].delay_buf dly_stage[70].delay_buf/I dly_stage[71].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_083_ _083_/D _083_/RN _105_/CLK _083_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
Xdly_stage[89].delay_buf dly_stage[89].delay_buf/I dly_stage[90].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_0_42 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_21_205 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_21_216 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[38].delay_buf dly_stage[38].delay_buf/I dly_stage[39].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_066_ _079_/A1 _078_/A2 _099_/RN VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__nor2_1
Xedge_dly_stage[15].edge_delay_buf edge_dly_stage[15].edge_delay_buf/I clk_i_dly_inv_23/I  VDD VDD
+ VSS VSS gf180mcu_fd_sc_mcu7t5v0__buf_1
X_049_ _088_/Q input2/Z _105_/Q _088_/D VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__mux2_2
XFILLER_15_2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[258].delay_buf dly_stage[258].delay_buf/I dly_stage[259].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_29_168 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_29_70 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_32
Xdly_stage[187].delay_buf dly_stage[187].delay_buf/I dly_stage[188].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_19_190 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[207].delay_buf dly_stage[207].delay_buf/I dly_stage[208].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[136].delay_buf dly_stage[136].delay_buf/I dly_stage[137].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_16_171 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xoutput3 _087_/Q dac_ctrl[0] VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyd_1
XFILLER_22_185 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_TAPCELL_ROW_24_136 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[88].delay_buf dly_stage[88].delay_buf/I dly_stage[89].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XTAP_TAPCELL_ROW_21_128 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_6_115 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
X_082_ _082_/D _082_/RN _105_/CLK _082_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XFILLER_17_18 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_17_29 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_5_192 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[37].delay_buf dly_stage[37].delay_buf/I dly_stage[38].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_23_72 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[257].delay_buf dly_stage[257].delay_buf/I dly_stage[258].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_065_ _079_/A1 _078_/A2 _098_/RN VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_12_206 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_9_74 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[186].delay_buf dly_stage[186].delay_buf/I dly_stage[187].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_048_ _048_/I _079_/A2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__inv_1
Xdly_stage[206].delay_buf dly_stage[206].delay_buf/I dly_stage[207].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_20_73 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_29_147 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_4_235 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xdly_stage[135].delay_buf dly_stage[135].delay_buf/I dly_stage[136].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_26_128 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_17_139 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_25_150 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_TAPCELL_ROW_27_145 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[87].delay_buf dly_stage[87].delay_buf/I dly_stage[88].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xoutput4 _086_/Q dac_ctrl[1] VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyd_1
XFILLER_16_183 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XTAP_TAPCELL_ROW_24_137 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_13_142 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
Xdly_stage[36].delay_buf dly_stage[36].delay_buf/I dly_stage[37].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XTAP_TAPCELL_ROW_21_129 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_27_212 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
X_081_ _081_/D _081_/RN _105_/CLK _081_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XFILLER_5_2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XPHY_EDGE_ROW_16_Right_16 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_EDGE_ROW_25_Right_25 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[256].delay_buf dly_stage[256].delay_buf/I dly_stage[257].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[185].delay_buf dly_stage[185].delay_buf/I dly_stage[186].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_15_237 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XPHY_EDGE_ROW_29_Left_59 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[205].delay_buf dly_stage[205].delay_buf/I dly_stage[206].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_064_ _079_/A1 _079_/A2 _097_/RN VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__nor2_1
Xdly_stage[134].delay_buf dly_stage[134].delay_buf/I dly_stage[135].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_11_240 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_15_4 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_7_200 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
X_047_ _081_/Q _063_/A1 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__clkinv_1
XFILLER_29_104 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XPHY_EDGE_ROW_2_Right_2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[86].delay_buf dly_stage[86].delay_buf/I dly_stage[87].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_20_30 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_1_228 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_26_107 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XPHY_EDGE_ROW_16_Left_46 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_25_184 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XTAP_TAPCELL_ROW_27_146 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xoutput5 _085_/Q dac_ctrl[2] VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyd_1
Xdly_stage[35].delay_buf dly_stage[35].delay_buf/I dly_stage[36].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_22_121 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_22_198 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XTAP_TAPCELL_ROW_24_138 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[255].delay_buf dly_stage[255].delay_buf/I dly_stage[256].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_13_198 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_9_125 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[184].delay_buf dly_stage[184].delay_buf/I dly_stage[185].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_080_ _080_/A1 _080_/A2 _080_/ZN VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_18_213 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[204].delay_buf dly_stage[204].delay_buf/I dly_stage[205].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_24_205 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_5_194 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[133].delay_buf dly_stage[133].delay_buf/I dly_stage[134].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_15_205 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XPHY_EDGE_ROW_4_Left_34 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
X_063_ _063_/A1 _104_/Q _063_/B _081_/D VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__oai21_1
Xdly_stage[85].delay_buf dly_stage[85].delay_buf/I dly_stage[86].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_7_212 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
X_046_ _082_/Q _061_/A1 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__clkinv_1
XFILLER_29_116 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_29_138 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[34].delay_buf dly_stage[34].delay_buf/I dly_stage[35].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_13_2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_6_22 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[254].delay_buf dly_stage[254].delay_buf/I dly_stage[255].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_25_196 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XTAP_TAPCELL_ROW_27_147 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xoutput6 _084_/Q dac_ctrl[3] VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyd_1
XFILLER_0_240 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[183].delay_buf dly_stage[183].delay_buf/I dly_stage[184].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
.ends



.include $::180MCU_MODELS/design.ngspice
.include $PDK_ROOT/gf180mcuD/libs.ref/gf180mcu_fd_sc_mcu7t5v0/spice/gf180mcu_fd_sc_mcu7t5v0.spice
.lib $::180MCU_MODELS/sm141064.ngspice typical
.lib $::180MCU_MODELS/smbb000149.ngspice typical
.lib /foss/pdks/gf180mcuD/libs.tech/ngspice/sm141064.ngspice cap_mim
.lib /foss/pdks/gf180mcuD/libs.tech/ngspice/sm141064.ngspice mimcap_typical



.tran 10n 1000n uic
.ic v(VX)=1.65 v(VX_LSB)=1.65

.control
run
wrdata trans_gate.txt v(vin) v(vsample) v(clk)
wrdata comparator.txt v(clk_o) v(outp) v(outn) v(clk)
wrdata logic.txt v(ctrl0) v(ctrl1) v(ctrl2) v(ctrl3) v(ctrl4) v(ctrl5) v(ctrl6) v(ctrl7) v(dout0)
+ v(dout1) v(dout2) v(dout3) v(dout4) v(dout5) v(dout6) v(dout7) v(clk)
wrdata cdac.txt v(vref) v(vx) v(vx_lsb) v(vsample)
.endc


**** end user architecture code
**.ends
.end
